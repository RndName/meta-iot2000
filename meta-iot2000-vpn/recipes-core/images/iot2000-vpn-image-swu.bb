require iot2000-vpn-image.bb
require vpn-image-swu.inc
